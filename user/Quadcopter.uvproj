# Keil uVision project Quadcopter.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Quadcopter +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Core\CM3;..\STM32F10x_FWLib\inc;..\FreeRTOS\include;..\FreeRTOS\portable;..\config;..\drivers\interface;..\hal\interface;..\modules\interface;..\utils\interface
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group STM32_LIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_cec.c stm32f10x_tim.c
  group FreeRTOS
    ../FreeRTOS/: event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group config
    ../config/: config.h FreeRTOSConfig.h nvicconf.h stm32f10x_conf.h
  group aplications
    ../init/: main.c
  group driver
    ../drivers/src/: nvic.c
